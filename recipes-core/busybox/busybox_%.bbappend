FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://diary.cfg"